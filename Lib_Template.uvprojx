# Keil uVision project Lib_Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lib_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\buzzer;.\APP\digital_tube;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\adc;.\APP\iic;.\APP\24cxx;.\APP\can;.\APP\spi;.\APP\flash;.\APP\DS18B20;.\DevWrapper;.\APP\esp8266\ESP8266_drive;.\APP\esp8266\ESP8266_Public;.\APP\esp8266\STA_TCPClent_Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: stm32f10x_it.c main.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ./APP/DS18B20/: APP_DS18B20.c DS18B20Util.c
    ./APP/led/: led.c
  group Public
    ./Public/: BitBand.c SysTick.c usart.c
  group DevWrapper
    ./DevWrapper/: DevWrapperIO.c
  group ESP8266
    ./APP/esp8266/ESP8266_drive/: esp8266_drive.c
    ./APP/esp8266/ESP8266_Public/: esp8266_public.c
    ./APP/esp8266/STA_TCPClent_Test/: sta_tcpclent_test.c
